/*
 * UTF-8 decode + small 8×8 bitmap subset for Chinese on the LED matrix.
 * Add rows to k_glyphs[] (sorted by cp) to extend coverage.
 */
#include <stddef.h>
#include <string.h>

#include "cjk8x8.h"

typedef struct {
    uint32_t cp;
    uint8_t rows[8];
} CjkGlyph;

/* Sorted by Unicode codepoint (binary search). */
static const CjkGlyph k_glyphs[] = {
    /* clang-format off */
    { 0x4E16, { 0x42, 0x42, 0x42, 0x7E, 0x42, 0x42, 0x42, 0x42 } }, /* 世 */
    { 0x4E2D, { 0x18, 0x18, 0xFF, 0x18, 0x18, 0x7E, 0x18, 0x18 } }, /* 中 */
    { 0x4F60, { 0x66, 0x66, 0x66, 0x7E, 0x66, 0x66, 0x3C, 0x18 } }, /* 你 */
    { 0x5149, { 0x18, 0x24, 0x42, 0x81, 0x42, 0x24, 0x18, 0x18 } }, /* 光 */
    { 0x514B, { 0x7E, 0x42, 0x42, 0x7E, 0x42, 0x42, 0x42, 0x7E } }, /* 克 */
    { 0x5165, { 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x3C, 0x18 } }, /* 入 */
    { 0x56FD, { 0xFF, 0x81, 0xBD, 0xA5, 0xA5, 0xBD, 0x81, 0xFF } }, /* 国 */
    { 0x597D, { 0x18, 0x3C, 0x66, 0x66, 0x7E, 0x66, 0x66, 0x42 } }, /* 好 */
    { 0x5B57, { 0x10, 0x28, 0x44, 0x82, 0x44, 0x28, 0x10, 0x10 } }, /* 字 */
    { 0x601D, { 0x81, 0x42, 0x24, 0x18, 0x18, 0x18, 0x18, 0x18 } }, /* 思 */
    { 0x6587, { 0xFF, 0x18, 0x18, 0xFF, 0x18, 0x18, 0x18, 0xFF } }, /* 文 */
    { 0x662F, { 0x7E, 0x18, 0x18, 0x7E, 0x18, 0x18, 0x18, 0x7E } }, /* 是 */
    { 0x663E, { 0x7E, 0x42, 0x42, 0x7E, 0x42, 0x42, 0x42, 0x7E } }, /* 显 */
    { 0x6D4B, { 0x42, 0x44, 0x48, 0x50, 0x60, 0x50, 0x48, 0x44 } }, /* 测 */
    { 0x706F, { 0x18, 0x3C, 0x18, 0x7E, 0x18, 0x18, 0x18, 0x18 } }, /* 灯 */
    { 0x754C, { 0x81, 0x42, 0x24, 0x18, 0x24, 0x42, 0x81, 0xFF } }, /* 界 */
    { 0x7684, { 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x3E, 0x00 } }, /* 的 */
    { 0x793A, { 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF } }, /* 示 */
    { 0x8272, { 0x7E, 0x42, 0x42, 0x7E, 0x42, 0x42, 0x42, 0x7E } }, /* 色 */
    { 0x8BD5, { 0x40, 0x50, 0x48, 0x44, 0x42, 0x44, 0x48, 0x50 } }, /* 试 */
    { 0x8BED, { 0x7E, 0x42, 0x42, 0x7E, 0x42, 0x42, 0x42, 0x7E } }, /* 语 */
    { 0x8F93, { 0x24, 0x18, 0x24, 0x42, 0x81, 0x42, 0x24, 0x18 } }, /* 输 */
    /* 金 — avoid round “blob” shapes that read like © on 8×8; strokes read top→bottom */
    { 0x91D1, { 0x10, 0xFE, 0x10, 0x28, 0x44, 0xFE, 0x28, 0x44 } },
    { 0x9A6C, { 0x42, 0x66, 0x66, 0x7E, 0x66, 0x42, 0x42, 0x42 } }, /* 马 */
    /* clang-format on */
};

int utf8_decode(const char **s, uint32_t *cp_out)
{
    const unsigned char *p = (const unsigned char *)*s;

    if (p[0] < 0x80) {
        *cp_out = p[0];
        *s += 1;
        return 1;
    }
    if ((p[0] & 0xE0) == 0xC0 && p[1]) {
        *cp_out = ((uint32_t)(p[0] & 0x1F) << 6) | (p[1] & 0x3F);
        *s += 2;
        return 2;
    }
    if ((p[0] & 0xF0) == 0xE0 && p[1] && p[2]) {
        *cp_out =
            ((uint32_t)(p[0] & 0x0F) << 12) | ((uint32_t)(p[1] & 0x3F) << 6) | (p[2] & 0x3F);
        *s += 3;
        return 3;
    }
    if ((p[0] & 0xF8) == 0xF0 && p[1] && p[2] && p[3]) {
        *cp_out = ((uint32_t)(p[0] & 0x07) << 18) | ((uint32_t)(p[1] & 0x3F) << 12) |
                  ((uint32_t)(p[2] & 0x3F) << 6) | (p[3] & 0x3F);
        *s += 4;
        return 4;
    }

    *cp_out = 0xFFFD;
    *s += 1;
    return 1;
}

bool cjk8_lookup(uint32_t cp, uint8_t *rows)
{
    size_t lo = 0;
    size_t hi = sizeof(k_glyphs) / sizeof(k_glyphs[0]);
    while (lo < hi) {
        size_t mid = (lo + hi) / 2;
        if (k_glyphs[mid].cp == cp) {
            if (rows != NULL) {
                memcpy(rows, k_glyphs[mid].rows, 8);
            }
            return true;
        }
        if (k_glyphs[mid].cp < cp) {
            lo = mid + 1;
        } else {
            hi = mid;
        }
    }
    return false;
}
